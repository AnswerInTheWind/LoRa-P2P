# Keil uVision project LoRaCommon.uvprojx, settings and files
target NPIOT-LoRaWAN_-LWM-SDK (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32L051C8 STMicroelectronics
  pack: Keil.STM32L0xx_DFP.1.6.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x2000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: LoRaCommon +hex
  AfterMake: fromelf --bin --output=@L.bin !L
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_HAL_DRIVER,STM32L051xx,
  c include: ..\src;..\src\boards\;..\src\boards\driver;..\src\boards\stm32\cmsis;..\src\boards\stm32\mcu\stm32\STM32L0xx_HAL_Driver\Inc;..\src\mac;..\src\radio;..\src\radio\sx1276;..\src\osal;..\src\apps;..\src\mac\crypto;..\src\boards\stm32\mcu\stm32\cmsis;..\..\..\Public\NGprotocol;..\..\..\Public;..\..\..\Public\ADE7953
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group startup
    ../src/boards/stm32/cmsis/arm-std/: startup_stm32l051xx.s
  group radio
    ../src/radio/sx1276/: sx1276.c
  group boards\Hal
    ../src/boards/driver/: board.c gpio.c delay.c gpio-board.c sx1276-board.c spi-board.c timer.c rtc-board.c uart_board.c key_board.c led_board.c oled_board.c
    ../src/boards/: utilities.c
  group boards\STM32L0xx
    ../src/boards/stm32/cmsis/: system_stm32l0xx.c
    ../src/boards/stm32/mcu/stm32/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal.c stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_cortex.c stm32l0xx_hal_dma.c stm32l0xx_hal_flash.c stm32l0xx_hal_flash_ex.c stm32l0xx_hal_flash_ramfunc.c stm32l0xx_hal_gpio.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_pwr.c stm32l0xx_hal_pwr_ex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_rtc.c stm32l0xx_hal_rtc_ex.c stm32l0xx_hal_spi.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c stm32l0xx_hal_iwdg.c
  group mac
    ../src/mac/: LoRaPhy_interface.c
  group apps
    ../src/apps/: stm32l0xx_hal_msp.c stm32l0xx_it.c main.c
